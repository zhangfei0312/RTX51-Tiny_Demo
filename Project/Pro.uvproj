# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S003F4 HolyChip
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(32000000)
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group APP
    ./: STARTUP.A51
    ../user/: main.c
  group RTOS
    ../user/RTOS/: Conf_tny.A51 RTX51TNY.LIB
